Commit message: start_poses now robot independet and on environment

File: pycram/resources/worlds/kitchen.urdf (robot description, URDF)
Before this commit: robot iai_oven_area, 83 links, 82 joints
Links:
- link kitchen_island_surface: geometry collision box size=0.8 1.7 0.04
