Commit message: test

File: pycram/resources/worlds/test-kitchen-chat.urdf (robot description, URDF)
Before this commit: robot modern_kitchen_from_image, 2 links, 1 joints
Links:
- removed link room
Joints:
- removed joint world_to_room
