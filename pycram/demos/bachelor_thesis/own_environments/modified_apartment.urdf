Commit message: fixed pr2_apartment issues

File: pycram/demos/bachelor_thesis/own_environments/modified_apartment.urdf (robot description, URDF)
Before this commit: robot apartment, 93 links, 92 joints
Links:
- removed link coffe_machine
Joints:
- removed joint coffe_machine_joint
