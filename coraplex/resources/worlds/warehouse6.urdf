Commit message: nav in cramera

File: coraplex/resources/worlds/warehouse6.urdf (robot description, URDF)
Before this commit: robot warehouse6, 1 links, 0 joints
Links:
- link warehouse6: geometry visual mesh filename=warehouse6.glb
